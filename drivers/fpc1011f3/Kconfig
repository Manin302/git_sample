## drivers/fpc1011f3/Kconfig
```kconfig
menu "finger print"
config FPC1011F3
	bool "fpc support"
	depends on SPI
	default m 
endmenu
```
